include u-boot_2020.01.inc

SRC_URI_append_ni-txgrl = " \
    file://fw_env.config\
"